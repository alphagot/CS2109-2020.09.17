# Keil uVision project CS2110.uvproj, settings and files
target Target 1 (MCS-51)
  device: DP80390CPU Digital Core Design
  cpu: IRAM(0 - 0xFF) CLOCK(50000000) MOD_CONT MODDP2
  output: CS2110.omf +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
